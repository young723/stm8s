# IAR project qst_sensor.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: QST_CONFIG_QMP6988
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: qst_sensor.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG; QST_CONFIG_QMAX981; QST_CONFIG_QMP6988; QST_CONFIG_QMCX983
  ICCSTM8.CCIncludePath2: STM8S_StdPeriph_Driver\inc; \user
  ILINK.IlinkOutputFile: qst_sensor.out
  group (top)
    ./: main.c
  group BSP
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_uart1.c stm8s_wwdg.c
  group USER
    user/: bsp_eeprom.c bsp_timer.c delay.c qmaX981.c qmcX983.c qmp6988.c qst_i2c.c qst_spi.c
